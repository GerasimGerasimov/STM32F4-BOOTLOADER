# IAR project ALS.BOOTLOADER.ewp, settings and files
configuration blank (ARM)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ICM.4X.BOOTLOADER.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration STM32F407IGT6 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; SD_SDIO; HEAP_SIZE_SET
  ICCARM.CCIncludePath2: ..\; ..\..\..\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\CMSIS\Include; ..\..\..\CMSIS\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\CMSIS\STM32F4xx_StdPeriph_Driver; ..\STM32F4xx_Intmash_Driver; ..\Board; ..\IntmashLib; ..\IntmashLog; ..\Utilities; ..\Storages; ..\Bootloader; ..\ModbusConfig
  ICCARM.CCOptLevel: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: ALS.BOOTLOADER.hex
  group (top)
    ../: bootloader.cpp main.cpp stm32f4xx_it.c USARTStartInit.cpp USARTStartInit.h
  group CMSIS
    ../../../CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Board
    ../Board/: BoardLEDs.h init.c init.h
  group EWARMv6
    ../../../CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group IntmashLib
    ../IntmashLib/: crc16.c id.c ModbusSlave.cpp ModbusSlave.h
  group ModbusConfig
    ../ModbusConfig/: ModbusSlaveConf.cpp ModbusSlaveConf.h
  group StdPeriph_Driver
    ../../../CMSIS/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group STM32F4xx_Intmash_Driver
    ../STM32F4xx_Intmash_Driver/: STM32F4xx_Intmash_BKP.c STM32F4xx_Intmash_Flash.c STM32F4xx_intmash_MBbasicCommands.c STM32F4xx_Intmash_USART.c
  group Storages
    ../Storages/: ramdata.c
  group Utilites
    ../Utilities/: str.c
