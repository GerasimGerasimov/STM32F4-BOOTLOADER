<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ALS.BOOTLOADER.ewp</path>
    </project>
    <batchBuild />
</workspace>
