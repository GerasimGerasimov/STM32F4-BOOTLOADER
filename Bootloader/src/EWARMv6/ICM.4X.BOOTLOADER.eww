<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ICM.4X.BOOTLOADER.ewp</path>
    </project>
    <batchBuild />
</workspace>
