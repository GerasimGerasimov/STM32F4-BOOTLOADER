# IAR project DExS.M4CPU.VTEG.ewp, settings and files
configuration blank (ARM)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DExS.M4CPU.VTEG.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration STM32F407IGT6 (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; SD_SDIO; HEAP_SIZE_SET
  ICCARM.CCIncludePath2: ..\; ..\CMSIS\Device\ST\STM32F4xx\Include; ..\CMSIS\Include; ..\STM32F4xx_StdPeriph_Driver\inc; ..\STM32F4xx_StdPeriph_Driver; ..\STM32F4xx_Intmash_Driver; ..\DExS_M4CPU; ..\DExS.M4CPU_Driver; ..\IntmashLib; ..\IntmashLog; ..\Utilities; ..\Storages; ..\Bootloader; ..\ModbusConfig
  ICCARM.CCOptLevel: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: STM32-BOOTLOADER.hex
  group (top)
    ../: bootloader.c main.cpp stm32f4xx_it.c
  group CMSIS
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group DExS.M4CPU_Driver
    ../DExS_M4CPU/: init.c
  group EWARMv6
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group IntmashLib
    ../IntmashLib/: crc16.c id.c ModbusSlave.c
    ../Utilities/: mmach.c
  group ModbusConfig
    ../ModbusConfig/: ModbusSlaveConf.c
  group StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group STM32F4xx_Intmash_Driver
    ../STM32F4xx_Intmash_Driver/: STM32F4xx_Intmash_BKP.c STM32F4xx_Intmash_Flash.c STM32F4xx_intmash_MBbasicCommands.c STM32F4xx_Intmash_USART.c
  group Storages
    ../Storages/: CalibrationData.c ramdata.c
  group Utilites
    ../Utilities/: str.c
